# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Public;.\Setup\_IQRHandler;.\Setup\config;.\Setup\launch;.\Setup\static;.\App\led;.\App\usart;.\App\tftlcd
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: stm32f10x_it.c main.cpp
  group CMSIS
    ./Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_usart.c stm32f10x_fsmc.c
  group Public
    ./Public/: system.c systick.c
  group App
    ./App/led/: led.cpp
    ./App/tftlcd/: tftlcd.cpp
    ./App/usart/: usart.cpp
  group SetUp
    ./Setup/_IQRHandler/: _IQRHandler.cpp IQR_manager.cpp
    ./Setup/config/: config.cpp
    ./Setup/launch/: launch.cpp setup.cpp
    ./Setup/static/: static_manager.cpp
